# Keil uVision project proj.uvprojx, settings and files
target X-Track (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ACGU7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-Track
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LIBRARY_VERSION,ARDUINO=111
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\USER;..\Libraries\SdFat\src;..\Simulator\LVGL.Simulator;..\USER\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../USER/: main.cpp
  group App
    ../USER/App/: App.cpp
  group Pages
    ../USER/App/Pages/: AppFactory.cpp AppFactory.h Page.h
  group StatusBar
    ../USER/App/Pages/StatusBar/: StatusBar.cpp StatusBar.h
  group Common/DataPorc
    ../USER/App/Common/DataProc/: DataProc.h DataProc.cpp DP_Clock.cpp DP_GPS.cpp DP_Power.cpp DP_SportStatus.cpp
  group Pages/Dialplate
    ../USER/App/Pages/Dialplate/: Dialplate.cpp Dialplate.h DialplateModel.cpp DialplateModel.h DialplateView.cpp DialplateView.h
  group Pages/LiveMap
    ../USER/App/Pages/LiveMap/: LiveMap.cpp LiveMap.h LiveMapModel.cpp LiveMapModel.h LiveMapView.cpp LiveMapView.h
  group Pages/_Template
    ../USER/App/Pages/_Template/: Template.cpp Template.h TemplateModel.cpp TemplateModel.h TemplateView.cpp TemplateView.h
  group Resource
    ../USER/App/Resource/: ResourcePool.cpp ResourcePool.h
  group Resource/Font
    ../USER/App/Resource/Font/: font_bahnschrift_13.c font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_65.c
  group Resource/Image
    ../USER/App/Resource/Image/: img_src_gps_arrow.c img_src_gps_pin.c img_src_alarm.c img_src_battery.c img_src_locate.c img_src_menu.c img_src_origin_point.c img_src_satellite.c img_src_stop.c img_src_trip.c
  group Utils/lv_ext
    ../USER/App/Utils/lv_ext/: lv_anim_timeline.cpp lv_label_anim_effect.cpp lv_obj_ext_func.cpp lv_theme_custom.c
  group Utils/MapConv
    ../USER/App/Utils/MapConv/: MapConv.cpp MapConv.h
  group Utils/PageManager
    ../USER/App/Utils/PageManager/: PageBase.h PageFactory.h PageManager.h PageManagerBase.cpp PageManagerRouter.cpp PageManagerDrag.cpp PageManagerLog.h PageManagerState.cpp ResourceManager.cpp ResourceManager.h
  group Utils/DataCenter
    ../USER/App/Utils/DataCenter/: Account.cpp Account.h DataCenter.cpp DataCenter.h DataCenterLog.h
  group Utils/Filters
    ../USER/App/Utils/Filters/: Filters.c Filters.h
  group Basic
    ../USER/Basic/: SysConfig.h CommonMacro.h
  group Display
    ../USER/Display/: Display.h Display.cpp DisplayFault.cpp
  group HAL
    ../USER/HAL/: HAL.h HAL.cpp HAL_Backlight.cpp HAL_Clock.cpp HAL_GPS.cpp HAL_I2C_Scan.cpp HAL_IMU.cpp HAL_MAG.cpp HAL_Power.cpp HAL_SD_CARD.cpp HAL_Buzz.cpp HAL_Encoder.cpp HAL_Audio.cpp HAL_AHRS.cpp
  group lv_port
    ../USER/Display/lv_port/: lv_port_disp.cpp lv_port_indev.cpp lv_fs_sdfat.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/LIS3MDL/: LIS3MDL.cpp
    ../Libraries/LSM6DSM/: LSM6DSM.cpp
    ../Libraries/TinyGPSPlus/src/: TinyGPS++.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/TonePlayer/: TonePlayer.cpp
    ../Libraries/PingPongBuffer/: PingPongBuffer.c
  group lvgl
    ../Simulator/LVGL.Simulator/: lv_conf.h
    ../Simulator/LVGL.Simulator/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Simulator/LVGL.Simulator/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Simulator/LVGL.Simulator/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Simulator/LVGL.Simulator/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Simulator/LVGL.Simulator/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Simulator/LVGL.Simulator/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Simulator/LVGL.Simulator/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lv_examaple
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
    ../Simulator/LVGL.Simulator/lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c
    ../Simulator/LVGL.Simulator/lv_examples/src/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
  group SdFat
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group cm_backtrace
    ../Libraries/cm_backtrace/: cmb_cfg.h cm_backtrace.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c HardwareSerial.cpp Print.cpp Stream.cpp SPI.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: adc.c delay.c exti.c gpio.c timer.c pwm.c rtc.c extend_SRAM.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:BKPR 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:FMC 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:PWR 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:RTC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
